# Autodesk Inventor assembly: stator+guides
## iProperties
Created: 2009-09
Part Number: stator+guides
Document SubType Name: Assembly
Designer: brest1
Author: brest1
